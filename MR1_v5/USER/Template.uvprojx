# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --cpp11
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\BSP\encoder;..\BSP\gyro;..\MODEL\global_location;..\ACTION\location;..\ACTION\debug;..\BSP\m3508;..\BSP\can1;..\BSP\PID;..\MODEL\chassis_driver;..\ACTION\FSM;..\ACTION\moving;..\ACTION\moving;..\BSP\tim2;..\ACTION\task;..\BSP\robomodule;..\ACTION\throw_bone;..\ACTION\pick_bone;..\ACTION\relay;..\BSP\adc;..\BSP\symbol_sensor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../BSP/symbol_sensor/: symbol_sensor.c
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: readme.txt
  group BSP
    ../BSP/tim2/: tim2.c
    ../BSP/can1/: can1.c
    ../BSP/PID/: PID.c
    ../BSP/GYRO/: gyro.c
    ../BSP/ENCODER/: encoder.c
    ../BSP/m3508/: m3508.c
    ../BSP/robomodule/: robomodule.c
    ../BSP/adc/: adc.cpp
  group MODEL
    ../MODEL/global_location/: global_location.c
    ../MODEL/chassis_driver/: chassis_driver.c
  group ACTION
    ../ACTION/FSM/: FSM.c
    ../ACTION/task/: task.c
    ../ACTION/moving/: moving.c
    ../ACTION/location/: location.c
    ../ACTION/debug/: debug.c
    ../ACTION/relay/: relay.c
    ../ACTION/pick_bone/: pick_bone.c
    ../ACTION/throw_bone/: throw_bone.c
